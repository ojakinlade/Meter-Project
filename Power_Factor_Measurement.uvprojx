# Keil uVision project Power_Factor_Measurement.uvprojx, settings and files
target STM32F1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Power_Factor_Measurement
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main Application
    ./: main.c
  group High Level APIs
    ./: system.c system.h lm358.c lm358.h meas.c meas.h
  group Low Level APIs
    ./: afio.c afio.h clocks.c clocks.h exti.c exti.h gpio.c gpio.h gptm.c gptm.h systick.c systick.h adc.c adc.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
